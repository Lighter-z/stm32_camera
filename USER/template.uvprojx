# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWLIB\inc;..\CORE;..\DELAY;..\HARDWARE\LED;..\HARDWARE\KEY;..\USART;..\TFT;..\GUI;..\HARDWARE\FLASH;..\HARDWARE\SPI;..\HARDWARE\xpt2046;..\HARDWARE\SDIO;..\FATFS;..\MALLOC;..\USER;..\OV
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_adc.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group DELAY
    ../DELAY/: delay.c
  group MALLOC
    ../MALLOC/: malloc.c
  group TFT
    ../TFT/: tft.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/xpt2046/: xpt2046.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group FATFS
    ../FATFS/: pff.c diskio.c
  group GUI
    ../GUI/: GUI.C
  group OV
    ../OV/: ov7670.c OVbmp.c OVroot.c sccb.c
